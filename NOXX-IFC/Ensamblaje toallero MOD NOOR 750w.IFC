Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Ensamblaje toallero MOD NOOR 750w.IFC
Time: 2023-01-17T11:39:45
Written by: SwIFC
Made in: SolidWorks 2014

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
